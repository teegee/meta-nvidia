include nvidia-base.inc
include nvidia-kernel-module.inc
include nvidia-libs.inc

LIC_FILES_CHKSUM = "file://../LICENSE;md5=2cc00be68c1227a7c42ff3620ef75d05"

SRC_URI[md5sum] = "7039e333837e7148c7935f9a77abccde"
SRC_URI[sha256sum] = "6df2ca1a7420b6751bcaf257d321b14f4e5f7ca54d77a43514912a3792ece65a"
