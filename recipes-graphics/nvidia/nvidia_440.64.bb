include nvidia-base.inc
include nvidia-kernel-module.inc
include nvidia-libs.inc

LIC_FILES_CHKSUM = "file://../LICENSE;md5=2cc00be68c1227a7c42ff3620ef75d05"

SRC_URI[md5sum] = "ba746d5b5f50369139bbed47da04aa74"
SRC_URI[sha256sum] = "e13c9f1ba13262bb7a9c4bb8180f7beb09be2b17145f611a81e8cf92600b7575"

