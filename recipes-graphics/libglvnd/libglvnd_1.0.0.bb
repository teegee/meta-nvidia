include libglvnd.inc

# v1.0.0 tag
SRCREV = "005fd3a0c449f809d0128921da8ef6762fecffc9"
