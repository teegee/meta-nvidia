include libglvnd.inc

# v1.3.1 tag
SRCREV = "1c32de07074fee8edcb274899948b6551081ed54"

LIC_FILES_CHKSUM = "file://README.md;md5=0b2ad086cfa07ba77eb896cd981fc4a2"

